# Keil uVision project 1986ve9proj.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1986ve9proj +hex
  c flags: Optim=1 uC99=1
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;E:\1986BE92QI;E:\MyLIB_for_1986BE92QI\MDR_PORT\inc;E:\MyLIB_for_1986BE92QI\MDR_PORT\src;E:\MyLIB_for_1986BE92QI\MDR_TIMER\inc;E:\MyLIB_for_1986BE92QI\MDR_TIMER\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: main.c
  group cmsis
    ./CMSIS/CM3/CoreSupport/: core_cm3.h core_cmFunc.h core_cmInstr.h
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group spl
    ./MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_adc.h MDR32F9Qx_audio.h MDR32F9Qx_bkp.h MDR32F9Qx_can.h MDR32F9Qx_comp.h MDR32F9Qx_dac.h MDR32F9Qx_dma.h MDR32F9Qx_ebc.h MDR32F9Qx_eeprom.h MDR32F9Qx_i2c.h MDR32F9Qx_iwdg.h MDR32F9Qx_keypad.h MDR32F9Qx_led.h MDR32F9Qx_lib.h MDR32F9Qx_port.h MDR32F9Qx_power.h MDR32F9Qx_rst_clk.h MDR32F9Qx_ssp.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h MDR32F9Qx_usb.h MDR32F9Qx_wwdg.h
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group conf
    ./: MDR32F9Qx_board.h MDR32F9Qx_config.h
  group MyLIB
    E:/MyLIB_for_1986BE92QI/MDR_PORT/src/: MDR32F9Qx_button.c MDR32F9Qx_2led.c
    E:/MyLIB_for_1986BE92QI/MDR_TIMER/src/: MDR32F9Qx_PWM.c
